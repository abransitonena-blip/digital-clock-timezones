# Repository abransitonena-blip/digital-clock-timezones (continued)

## KiCad design hardware/ap-electric/plcb/kicad/AP_PLC_C24B.kicad_pcb

Schematic: AP_PLC_C24B.kicad_sch, AP Electric Industrial · AP PLC C24 rev A - 12 entradas, 12…

Parts:
C1, C2, C4, C7: 10uF 50V; C_1206_3216Metric
C3, C6, C11, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C27, C28, C29, C32, C33, C34, C35, C36: 100nF; C_0603_1608Metric
C5: 22uF 25V; C_1206_3216Metric
C8, C9: 22uF; C_0805_2012Metric
C10, C30: 10uF; C_0805_2012Metric
C12: 1uF; C_0603_1608Metric
C23: 4.7uF; C_0805_2012Metric
C24, C25: 18pF; C_0603_1608Metric
C26, C31: 10nF; C_0603_1608Metric
D1: SMBJ33A; D_SMB
D2: SS210; D_SMA
D3: B5819W; D_SOD-123
D4, D6: SM712; SOT-23
D5: BAT54C; SOT-23
DI1, DI2, DI3, DI4, DI5, DI6, DI7, DI8, DI9, DI10, DI11, DI12: 1N4148W; D_SOD-123
DL1, DL2, DL3, DL4, DL5, DL6, DL7, DL8, DL9, DL10, DL11, DL12: VERDE; LED_0603_1608Metric
DLK: VERDE; LED_0603_1608Metric
DP1, DP4, DP5, DP6: VERDE; LED_0603_1608Metric
DP2: ROJO; LED_0603_1608Metric
DP3, DP7, DP8: AMARILLO; LED_0603_1608Metric
DPW: VERDE; LED_0603_1608Metric
DQ1, DQ2, DQ3, DQ4, DQ5, DQ6, DQ7, DQ8, DQ9, DQ10, DQ11, DQ12: SS14; D_SMA
F1: MINI 3A; Fuseholder_Blade_Mini_Keystone_3568
J1: VIN 12-30V; JST_VH_B2P-VH_1x02_P3.96mm_Vertical
J2: USB-C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J16: KF128-5.08-3P; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
J14: HR911105A; RJ45_Hanrun_HR911105A_Horizontal
J15: BAT; PinHeader_1x02_P2.54mm_Vertical
JL1: AP LINK ENTRA; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
JL2: AP LINK SIGUE; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
JP1, JP4: 120R; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: POL A; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: POL B; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 47uH; L_Changjiang_FNR4030S
L2: 4.7uH; L_Changjiang_FNR4030S
LI1, LI2, LI3, LI4, LI5, LI6, LI7, LI8, LI9, LI10, LI11, LI12: VERDE; LED_0603_1608Metric
OK1, OK2, OK3, OK4, OK5, OK6, OK7, OK8, OK9, OK10, OK11, OK12: LTV-217-B; SOP-4_4.4x2.6mm_P1.27mm
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: NCV8406ASTT3G; SOT-223-3_TabPin2
R1, R2, R7, R10, R14, R17, R18, R24, R27, R28, R32, R33: 10k; R_0603_1608Metric
R3, R4: 4.7k; R_0603_1608Metric
R6, R15: 100k; R_0603_1608Metric
R8, R9: 5.1k; R_0603_1608Metric
R11, R31: 120; R_1206_3216Metric
R12, R13: 680; R_0603_1608Metric
R16: 1k; R_0603_1608Metric
R19: 12k; R_0603_1608Metric
R20, R21, R22, R23: 49.9; R_0603_1608Metric
R29: 0; R_0603_1608Metric
R30: 390; R_0603_1608Metric
RA1, RA2, RA3, RA4, RA5, RA6, RA7, RA8, RA9, RA10, RA11, RA12: 3.3k; R_0805_2012Metric
RB1: 56k; R_0603_1608Metric
RB2: 10k; R_0603_1608Metric
RC1, RC2, RC3, RC4, RC5, RC6, RC7, RC8, RC9, RC10, RC11, RC12: 3.3k; R_0805_2012Metric
RD1, RD2, RD3, RD4, RD5, RD6, RD7, RD8, RD9, RD10, RD11, RD12: 10k; R_0603_1608Metric
RL1, RL2, RL3, RL4, RL5, RL6, RL7, RL8, RL9, RL10, RL11, RL12: 15k; R_0603_1608Metric
RLK: 1k; R_0603_1608Metric
RP1, RP2, RP3, RP4, RP5, RP6, RP7, RP8: 1k; R_0603_1608Metric
RPW: 1k; R_0603_1608Metric
RQ1, RQ2, RQ3, RQ4, RQ5, RQ6, RQ7, RQ8, RQ9, RQ10, RQ11, RQ12: 10k; R_0603_1608Metric
RS1, RS2, RS3, RS4, RS5, RS6, RS7, RS8, RS9, RS10, RS11, RS12: 2.2k; R_0603_1608Metric
SW1: MODO; SW_Push_1P1T_XKB_TS-1187A
SW2: RESET; SW_Push_1P1T_XKB_TS-1187A
SW3: RUN/STOP; SW_Push_1P1T_XKB_TS-1187A
TP1: TP +V; TestPoint_Pad_D1.5mm
TP2: TP 5V; TestPoint_Pad_D1.5mm
TP3: TP 3V3; TestPoint_Pad_D1.5mm
TP4: TP GND; TestPoint_Pad_D1.5mm
TP5: TP SDA; TestPoint_Pad_D1.5mm
TP6: TP SCL; TestPoint_Pad_D1.5mm
TP7: TP A; TestPoint_Pad_D1.5mm
TP8: TP B; TestPoint_Pad_D1.5mm
TP9: TP SI; TestPoint_Pad_D1.5mm
TP10: TP SO; TestPoint_Pad_D1.5mm
U1: LMR16006XDDC; SOT-23-6
U2: AP63203WU; TSOT-23-6
U3: ESP32-S3-WROOM-1
U4: USBLC6-2SC6; SOT-23-6
U5, U18: SP3485EN; SOIC-8_3.9x4.9mm_P1.27mm
U6, U7, U8, U9, U15: TCA9554PWR; TSSOP-16_4.4x5mm_P0.65mm
U10, U11, U12: 74HCT125D; SOIC-14_3.9x8.7mm_P1.27mm
U16: W5500; LQFP-48_7x7mm_P0.5mm
U17: PCF8563T/5,518; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32.768kHz 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
/3V3: C8.1, C9.1, C10.1, C11.1, C14.1, C15.1, C16.1, C17.1, C18.1, C22.1, C27.1, C28.1, C29.1, C30.1, C36.1, D5.1, JP2.1 (A), L2.2, R1.1, R2.1, R3.1, R4.1, R15.1, R18.1, R24.1, R27.1, R28.1, R29.1, R33.1, RLK.1, RPW.1, RQ1.1, RQ2.1, RQ3.1, RQ4.1, RQ5.1, RQ6.1, RQ7.1, RQ8.1, RQ9.1, RQ10.1, RQ11.1, RQ12.1, TP3.1, U2.1 (FB), U3.2 (3V3), U5.8 (VCC), U6.16 (VDD), U7.1 (A0), U7.16 (VDD), U8.2 (A1), U8.16 (VDD), U9.1 (A0), U9.2 (A1), U9.16 (VDD), U15.3 (A2), U15.16 (VDD), U16.4 (AVDD), U16.8 (AVDD), U16.11 (AVDD), U16.15 (AVDD), U16.17 (AVDD), U16.21 (AVDD), U16.28 (VDD), U16.43 (PMODE2), U16.44 (PMODE1), U16.45 (PMODE0), U18.8 (VCC)
/BOOT: R2.2, SW1.1, U3.27 (IO0)
/BRS: C34.1, R27.2, SW3.1, U15.9 (P4)
/BST: C3.1, U1.1 (CB)
/BSTP: C6.1, U2.6 (BST)
/CC1U: J2.A5 (CC1), R8.1
/CC2U: J2.B5 (CC2), R9.1
/COMI: DI1.2 (A), DI2.2 (A), DI3.2 (A), DI4.2 (A), DI5.2 (A), DI6.2 (A), DI7.2 (A), DI8.2 (A), DI9.2 (A), DI10.2 (A), DI11.2 (A), DI12.2 (A), J7.1, J7.2, J7.3, OK1.2, OK2.2, OK3.2, OK4.2, OK5.2, OK6.2, OK7.2, OK8.2, OK9.2, OK10.2, OK11.2, OK12.2, RS1.2, RS2.2, RS3.2, RS4.2, RS5.2, RS6.2, RS7.2, RS8.2, RS9.2, RS10.2, RS11.2, RS12.2
/E1: OK1.4, RQ1.2, U8.4 (P0)
/E2: OK2.4, RQ2.2, U8.5 (P1)
/E3: OK3.4, RQ3.2, U8.6 (P2)
/E4: OK4.4, RQ4.2, U8.7 (P3)
/E5: OK5.4, RQ5.2, U8.9 (P4)
/E6: OK6.4, RQ6.2, U8.10 (P5)
/E7: OK7.4, RQ7.2, U8.11 (P6)
/E8: OK8.4, RQ8.2, U8.12 (P7)
/E9: OK9.4, RQ9.2, U15.4 (P0)
/E10: OK10.4, RQ10.2, U15.5 (P1)
/E11: OK11.4, RQ11.2, U15.6 (P2)
/E12: OK12.4, RQ12.2, U15.7 (P3)
/EN: C12.1, R1.2, SW2.1, U3.3 (EN)
/ETH_CS: R18.2, U3.32 (IO39), U16.32 (~SCS)
/ETH_CT: C32.1, J14.4 (TCT), J14.5 (RCT), R29.2
/ETH_INT: R33.2, U3.31 (IO38), U16.36 (~INT)
/ETH_MISO: U3.34 (IO41), U16.34 (MISO)
/ETH_MOSI: U3.33 (IO40), U16.35 (MOSI)
/ETH_RST: C33.1, R24.2, U3.38 (IO2), U16.37 (~RST)
/ETH_RXN: J14.6 (RD-), R23.1, U16.5 (RXN)
/ETH_RXP: J14.3 (RD+), R22.1, U16.6 (RXP)
/ETH_SCK: U3.35 (IO42), U16.33 (SCLK)
/ETH_TERM: C31.1, R20.2, R21.2, R22.2, R23.2
/ETH_TXN: J14.2 (TD-), R21.1, U16.1 (TXN)
/ETH_TXP: J14.1 (TD+), R20.1, U16.2 (TXP)
/EXMID: R19.2, R30.1
/EXRES: R19.1, U16.10 (EXRES1)
/FB: RB1.2, RB2.1, U1.3 (FB)
/G1: Q1.1 (G), U10.3
/G2: Q2.1 (G), U10.6
/G3: Q3.1 (G), U10.8
/G4: Q4.1 (G), U10.11
/G5: Q5.1 (G), U11.3
/G6: Q6.1 (G), U11.6
/G7: Q7.1 (G), U11.8
/G8: Q8.1 (G), U11.11
/G9: Q9.1 (G), U12.3
/G10: Q10.1 (G), U12.6
/G11: Q11.1 (G), U12.8
/G12: Q12.1 (G), U12.11
/GND: C1.2, C2.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, D1.2 (A2), D2.2 (A), D4.3 (common), D6.3 (common), DP1.1 (K), DP2.1 (K), DP3.1 (K), DP4.1 (K), DP5.1 (K), DP6.1 (K), DP7.1 (K), DP8.1 (K), DPW.1 (K), J1.2, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J14.SH, J15.2, J16.3, JL1.4, JL2.4, JP3.2 (B), OK1.3, OK2.3, OK3.3, OK4.3, OK5.3, OK6.3, OK7.3, OK8.3, OK9.3, OK10.3, OK11.3, OK12.3, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), Q9.3 (S), Q10.3 (S), Q11.3 (S), Q12.3 (S), R7.2, R8.2, R9.2, R10.2, R17.2, R30.2, R32.2, RB2.2, RD1.2, RD2.2, RD3.2, RD4.2, RD5.2, RD6.2, RD7.2, RD8.2, RD9.2, RD10.2, RD11.2, RD12.2, SW1.2, SW2.2, SW3.2, TP4.1, U1.2 (GND), U2.4 (GND), U3.1 (GND), U3.40 (GND), U3.41 (GND), U4.2 (GND), U5.5 (GND), U6.1 (A0), U6.2 (A1), U6.3 (A2), U6.8 (GND), U7.2 (A1), U7.3 (A2), U7.8 (GND), U8.1 (A0), U8.3 (A2), U8.8 (GND), U9.3 (A2), U9.8 (GND), U10.1, U10.4, U10.7 (GND), U10.10, U10.13, U11.1, U11.4, U11.7 (GND), U11.10, U11.13, U12.1, U12.4, U12.7 (GND), U12.10, U12.13, U15.1 (A0), U15.2 (A1), U15.8 (GND), U16.3 (AGND), U16.9 (AGND), U16.14 (AGND), U16.16 (AGND), U16.19 (AGND), U16.23 (RSVD), U16.29 (GND), U16.38 (RSVD), U16.39 (RSVD), U16.40 (RSVD), U16.41 (RSVD), U16.42 (RSVD), U16.48 (AGND), U17.4 (VSS), U18.5 (GND), Y1.2 (G), Y1.4 (G)
/IA1: RA1.2, RC1.1
/IA2: RA2.2, RC2.1
/IA3: RA3.2, RC3.1
/IA4: RA4.2, RC4.1
/IA5: RA5.2, RC5.1
/IA6: RA6.2, RC6.1
/IA7: RA7.2, RC7.1
/IA8: RA8.2, RC8.1
/IA9: RA9.2, RC9.1
/IA10: RA10.2, RC10.1
/IA11: RA11.2, RC11.1
/IA12: RA12.2, RC12.1
/IB1: DI1.1 (K), LI1.2 (A), RC1.2
/IB2: DI2.1 (K), LI2.2 (A), RC2.2
/IB3: DI3.1 (K), LI3.2 (A), RC3.2
/IB4: DI4.1 (K), LI4.2 (A), RC4.2
/IB5: DI5.1 (K), LI5.2 (A), RC5.2
/IB6: DI6.1 (K), LI6.2 (A), RC6.2
/IB7: DI7.1 (K), LI7.2 (A), RC7.2
/IB8: DI8.1 (K), LI8.2 (A), RC8.2
/IB9: DI9.1 (K), LI9.2 (A), RC9.2
/IB10: DI10.1 (K), LI10.2 (A), RC10.2
/IB11: DI11.1 (K), LI11.2 (A), RC11.2
/IB12: DI12.1 (K), LI12.2 (A), RC12.2
/IL1: LI1.1 (K), OK1.1, RS1.1
/IL2: LI2.1 (K), OK2.1, RS2.1
/IL3: LI3.1 (K), OK3.1, RS3.1
/IL4: LI4.1 (K), OK4.1, RS4.1
/IL5: LI5.1 (K), OK5.1, RS5.1
/IL6: LI6.1 (K), OK6.1, RS6.1
/IL7: LI7.1 (K), OK7.1, RS7.1
/IL8: LI8.1 (K), OK8.1, RS8.1
/IL9: LI9.1 (K), OK9.1, RS9.1
/IL10: LI10.1 (K), OK10.1, RS10.1
/IL11: LI11.1 (K), OK11.1, RS11.1
/IL12: LI12.1 (K), OK12.1, RS12.1
/IN1: RD1.1, U6.4 (P0), U10.2
/IN1X: J3.1, RA1.1
/IN2: RD2.1, U6.5 (P1), U10.5
/IN2X: J3.2, RA2.1
/IN3: RD3.1, U6.6 (P2), U10.9
/IN3X: J3.3, RA3.1
/IN4: RD4.1, U6.7 (P3), U10.12
/IN4X: J4.1, RA4.1
/IN5: RD5.1, U6.9 (P4), U11.2
/IN5X: J4.2, RA5.1
/IN6: RD6.1, U6.10 (P5), U11.5
/IN6X: J4.3, RA6.1
/IN7: RD7.1, U6.11 (P6), U11.9
/IN7X: J5.1, RA7.1
/IN8: RD8.1, U6.12 (P7), U11.12
/IN8X: J5.2, RA8.1
/IN9: RD9.1, U7.4 (P0), U12.2
/IN9X: J5.3, RA9.1
/IN10: RD10.1, U7.5 (P1), U12.5
/IN10X: J6.1, RA10.1
/IN11: RD11.1, U7.6 (P2), U12.9
/IN11X: J6.2, RA11.1
/IN12: RD12.1, U7.7 (P3), U12.12
/IN12X: J6.3, RA12.1
/LA1: DL1.2 (A), RL1.2
/LA2: DL2.2 (A), RL2.2
/LA3: DL3.2 (A), RL3.2
/LA4: DL4.2 (A), RL4.2
/LA5: DL5.2 (A), RL5.2
/LA6: DL6.2 (A), RL6.2
/LA7: DL7.2 (A), RL7.2
/LA8: DL8.2 (A), RL8.2
/LA9: DL9.2 (A), RL9.2
/LA10: DL10.2 (A), RL10.2
/LA11: DL11.2 (A), RL11.2
/LA12: DL12.2 (A), RL12.2
/LCOM: RP3.1, U9.6 (P2)
/LCOMA: DP3.2 (A), RP3.2
/LFAL: RP2.1, U9.5 (P1)
/LFALA: DP2.2 (A), RP2.2
/LINKLED: DLK.1 (K), U16.25 (LINKLED)
/LKA: DLK.2 (A), RLK.2
/LNET: RP4.1, U9.7 (P3)
/LNETA: DP4.2 (A), RP4.2
/LRUN: RP1.1, U9.4 (P0)
/LRUNA: DP1.2 (A), RP1.2
/LU1: RP5.1, U9.9 (P4)
/LU1A: DP5.2 (A), RP5.2
/LU2: RP6.1, U9.10 (P5)
/LU2A: DP6.2 (A), RP6.2
/LU3: RP7.1, U9.11 (P6)
/LU3A: DP7.2 (A), RP7.2
/LU4: RP8.1, U9.12 (P7)
/LU4A: DP8.2 (A), RP8.2
/MBT: JP4.1 (A), R31.2
/MB_A: D6.1 (A1), J16.1, R31.1, U18.6 (A)
/MB_B: D6.2 (A2), J16.2, JP4.2 (B), U18.7 (B)
/MB_DE: R32.1, U3.6 (IO6), U18.2 (~RE), U18.3 (DE)
/MB_RX: U3.4 (IO4), U18.1 (RO)
/MB_TX: U3.5 (IO5), U18.4 (DI)
/OSCI: U17.1 (OSCI), Y2.1
/OSCO: U17.2 (OSCO), Y2.2
/PA: JP2.2 (B), R12.1
/PB: JP3.1 (A), R13.2
/PWA: DPW.2 (A), RPW.2
/Q1: DL1.1 (K), DQ1.2 (A), J8.1, Q1.2 (D)
/Q2: DL2.1 (K), DQ2.2 (A), J8.3, Q2.2 (D)
/Q3: DL3.1 (K), DQ3.2 (A), J9.1, Q3.2 (D)
/Q4: DL4.1 (K), DQ4.2 (A), J9.3, Q4.2 (D)
/Q5: DL5.1 (K), DQ5.2 (A), J10.1, Q5.2 (D)
/Q6: DL6.1 (K), DQ6.2 (A), J10.3, Q6.2 (D)
/Q7: DL7.1 (K), DQ7.2 (A), J11.1, Q7.2 (D)
/Q8: DL8.1 (K), DQ8.2 (A), J11.3, Q8.2 (D)
/Q9: DL9.1 (K), DQ9.2 (A), J12.1, Q9.2 (D)
/Q10: DL10.1 (K), DQ10.2 (A), J12.3, Q10.2 (D)
/Q11: DL11.1 (K), DQ11.2 (A), J13.1, Q11.2 (D)
/Q12: DL12.1 (K), DQ12.2 (A), J13.3, Q12.2 (D)
/RSA: D4.1 (A1), JL1.3, JL2.3, R11.1, R12.2, TP7.1, U5.6 (A)
/RSB: D4.2 (A2), JL1.2, JL2.2, JP1.2 (B), R13.1, TP8.1, U5.7 (B)
/RS_DE: R10.1, U3.9 (IO16), U5.2 (~RE), U5.3 (DE)
/RS_RX: U3.11 (IO18), U5.1 (RO)
/RS_TX: U3.10 (IO17), U5.4 (DI)
/SCL: R4.2, TP6.1, U3.17 (IO9), U6.14 (SCL), U7.14 (SCL), U8.14 (SCL), U9.14 (SCL), U15.14 (SCL), U17.6 (SCL)
/SDA: R3.2, TP5.1, U3.12 (IO8), U6.15 (SDA), U7.15 (SDA), U8.15 (SDA), U9.15 (SDA), U15.15 (SDA), U17.5 (SDA)
/SENSE_I: R14.2, R15.2, TP9.1, U3.19 (IO11)
/SENSE_IC: JL1.1, R14.1
/SENSE_O: R16.1, TP10.1, U3.20 (IO12)
/SENSE_OC: JL2.1, R16.2, R17.1
/SW: C3.2, D2.1 (K), L1.2, U1.6 (SW)
/SWP: C6.2, L2.1, U2.5 (SW)
/TERM: JP1.1 (A), R11.2
/TOCAP: C23.1, U16.20 (TOCAP)
/UN: R28.2, U7.9 (P4), U7.10 (P5), U7.11 (P6), U7.12 (P7), U15.10 (P5), U15.11 (P6), U15.12 (P7)
/USB_DN: J2.A7 (D-), J2.B7 (D-), U3.13 (USB_D-), U4.1 (I/O1), U4.6 (I/O1)
/USB_DP: J2.A6 (D+), J2.B6 (D+), U3.14 (USB_D+), U4.3 (I/O2), U4.4 (I/O2)
/V1P2: C26.1, U16.22 (1V2O)
/V5: C5.1, C7.1, C19.1, C20.1, C21.1, D3.1 (K), L1.1, RB1.1, TP2.1, U2.2 (EN), U2.3 (IN), U10.14 (VCC), U11.14 (VCC), U12.14 (VCC)
/V24: C1.1, C2.1, C4.1, D1.1 (A1), DQ1.1 (K), DQ2.1 (K), DQ3.1 (K), DQ4.1 (K), DQ5.1 (K), DQ6.1 (K), DQ7.1 (K), DQ8.1 (K), DQ9.1 (K), DQ10.1 (K), DQ11.1 (K), DQ12.1 (K), F1.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.2, R6.1, RL1.1, RL2.1, RL3.1, RL4.1, RL5.1, RL6.1, RL7.1, RL8.1, RL9.1, RL10.1, RL11.1, RL12.1, TP1.1, U1.4 (~SHDN), U1.5 (VIN)
/VBAT: D5.2, J15.1
/VBUS: D3.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U4.5 (VBUS)
/VIN_RAW: F1.1, J1.1
/VRTC: C35.1, D5.3, U17.8 (VDD)
/VSENSE: C13.1, R6.2, R7.1, U3.7 (IO7)
/XI: C24.1, U16.30 (XI/CLKIN), Y1.1
/XO: C25.1, U16.31 (XO), Y1.3

Notes on the sheet:
AP Electric Industrial · AP PLC C24 rev A (CONCEPTO): 12 x NCV8406A, 3 x 74HCT125, 5 x TCA9554 (0x20-0x24), 12 entradas de 12-30 V LTV-217, W5500 + RJ45 (Ethernet), SP3485 + 2 x JST XH4 (AP LINK), ESP32-C3. Sin red de CA.

Board: 2 copper layers, 298 parts (0 on the bottom side), 190 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3
